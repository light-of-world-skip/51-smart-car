# Keil uVision project led.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: timer.c motor.c sensor.c control.c track.c uart.c remote.c main.c config.h system.h timer.h motor.h sensor.h control.h track.h uart.h remote.h
